# Keil uVision project Project.uvprojx, settings and files
target IOTA-Client_CRYPTOLIB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: IOTA-Client
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: STM32L4S5xx,USE_HAL_DRIVER,__ORDER_LITTLE_ENDIAN__=1,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_WIFI,CRYPTO_USE_STLIB
  c misc: --diag_suppress=2803
  c include: ../Inc;../Inc/Cryptolib_Init;../Inc/Tests;../Inc/Time;../Inc/Utils;../Inc/Wallet;../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../Drivers/BSP/Components/es_wifi;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis3mdl;../../../../../Drivers/BSP/Components/lps22hb;../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../Drivers/BSP/Components/vl53l0x;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Middlewares/ST/cryptolib/include;../../../../../Middlewares/ST/STM32_Connect_Library/Includes;../../../../../Middlewares/Third_Party/cJSON;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../Middlewares/Third_Party/IOTA_C/client;../../../../../Middlewares/Third_Party/IOTA_C/client/api;../../../../../Middlewares/Third_Party/IOTA_C/client/api/v1;../../../../../Middlewares/Third_Party/IOTA_C/client/network;../../../../../Middlewares/Third_Party/IOTA_C/core;../../../../../Middlewares/Third_Party/IOTA_C/core/models;../../../../../Middlewares/Third_Party/IOTA_C/core/models/inputs;../../../../../Middlewares/Third_Party/IOTA_C/core/models/outputs;../../../../../Middlewares/Third_Party/IOTA_C/core/models/payloads;../../../../../Middlewares/Third_Party/IOTA_C/core/utils;../../../../../Middlewares/Third_Party/IOTA_C/crypto;../../../../../Middlewares/Third_Party/IOTA_C/wallet;../../../../../Middlewares/Third_Party/libsodium/include/sodium;../../../../../Middlewares/Third_Party/libsodium/include/sodium-blake2b;../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../Middlewares/Third_Party/tinyhttp;../../../../../Middlewares/Third_Party/Unity;../../../../../Middlewares/Third_Party/uthash
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: .\Project.sct
  group Application/MDK-ARM
    ./: startup_stm32l4s5xx.s
  group Application/Cryptolib_Init
    ../Src/Cryptolib_Init/: cmox_low_level.c
  group Application/Tests
    ../Src/Tests/: test_crypto.c test_find_message.c test_get_balance.c test_get_message.c test_get_output.c test_get_tips.c test_info.c test_message_builder.c test_outputs_from_address.c test_response_error.c test_send_message.c
  group Application/Time
    ../Src/Time/: STM32CubeRTCInterface.c timedate.c timingSystem.c
  group Application/User
    ../Src/: flash_l4.c main.c mbedtls_entropy.c net_conf.c stm32l4xx_hal_msp.c stm32l4xx_it.c vl53l0x_platform.c vl53l0x_proximity.c
  group Application/Utils
    ../Src/Utils/: cloud.c iot_flash_config.c sensors_data.c set_credentials.c
  group Application/Wallet
    ../Src/Wallet/: console.c iota_wallet.c menu.c send_indexation_msg.c sensor_indexation_msg.c serial_comm.c terminal_manager.c test_wallet.c wallet_get_balance.c wallet_send_tx.c
  group Drivers/BSP/B-L4S5I-IOT01A
    ../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_bus.c stm32l475e_iot01_env_sensors.c stm32l475e_iot01_motion_sensors.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
    ../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Middlewares/ST/cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto_CM4_crc.a
  group Middlewares/ST/STM32_Connect_Library/core
    ../../../../../Middlewares/ST/STM32_Connect_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c
  group Middlewares/ST/STM32_Connect_Library/netif
    ../../../../../Middlewares/ST/STM32_Connect_Library/netif/wifi_if/es_wifi/: net_es_wifi.c
  group Middlewares/ST/STM32_Connect_Library/services
    ../../../../../Middlewares/ST/STM32_Connect_Library/services/: net_mbedtls.c
  group Middlewares/Third_Party/cJSON
    ../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Third_Party/IOTA_C/client/api
    ../../../../../Middlewares/Third_Party/IOTA_C/client/api/: json_utils.c message.c message_builder.c
  group Middlewares/Third_Party/IOTA_C/client/api/v1
    ../../../../../Middlewares/Third_Party/IOTA_C/client/api/v1/: find_message.c get_balance.c get_health.c get_message.c get_node_info.c get_output.c get_outputs_from_address.c get_tips.c response_error.c send_message.c
  group Middlewares/Third_Party/IOTA_C/client/network
    ../../../../../Middlewares/Third_Party/IOTA_C/client/network/: http_lib.c
  group Middlewares/Third_Party/IOTA_C/core
    ../../../../../Middlewares/Third_Party/IOTA_C/core/: address.c seed.c
  group Middlewares/Third_Party/IOTA_C/core/models
    ../../../../../Middlewares/Third_Party/IOTA_C/core/models/: models_message.c
  group Middlewares/Third_Party/IOTA_C/core/models/inputs
    ../../../../../Middlewares/Third_Party/IOTA_C/core/models/inputs/: utxo_input.c
  group Middlewares/Third_Party/IOTA_C/core/models/outputs
    ../../../../../Middlewares/Third_Party/IOTA_C/core/models/outputs/: outputs.c
  group Middlewares/Third_Party/IOTA_C/core/models/payloads
    ../../../../../Middlewares/Third_Party/IOTA_C/core/models/payloads/: indexation.c transaction.c
  group Middlewares/Third_Party/IOTA_C/core/utils
    ../../../../../Middlewares/Third_Party/IOTA_C/core/utils/: bech32.c byte_buffer.c iota_str.c slip10.c
  group Middlewares/Third_Party/IOTA_C/clrypto
    ../../../../../Middlewares/Third_Party/IOTA_C/crypto/: iota_crypto.c
  group Middlewares/Third_Party/IOTA_C/wallet
    ../../../../../Middlewares/Third_Party/IOTA_C/wallet/: wallet.c
  group Middlewares/Third_Party/libsodium/library
    ../../../../../Middlewares/Third_Party/libsodium/library/MDK-ARM/: sodium.lib sodium_blake2b.lib
  group Middlewares/Third_Party/MbedTLS
    ../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Party/tinyhttp
    ../../../../../Middlewares/Third_Party/tinyhttp/: chunk.c header.c http.c
  group Middlewares/Third_Party/Unity
    ../../../../../Middlewares/Third_Party/Unity/: unity.c
target IOTA-Client_SODIUM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: as above
  output: IOTA-Client
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: STM32L4S5xx,USE_HAL_DRIVER,__ORDER_LITTLE_ENDIAN__=1,__BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__,USE_HAL_DRIVER,SENSOR,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_WIFI,CRYPTO_USE_SODIUM
  c misc: --diag_suppress=2803
  c include: ../Inc;../Inc/Tests;../Inc/Time;../Inc/Utils;../Inc/Wallet;../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../Drivers/BSP/Components/es_wifi;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis3mdl;../../../../../Drivers/BSP/Components/lps22hb;../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../Drivers/BSP/Components/vl53l0x;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Middlewares/ST/STM32_Connect_Library/Includes;../../../../../Middlewares/Third_Party/cJSON;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../Middlewares/Third_Party/IOTA_C/client;../../../../../Middlewares/Third_Party/IOTA_C/client/api;../../../../../Middlewares/Third_Party/IOTA_C/client/api/v1;../../../../../Middlewares/Third_Party/IOTA_C/client/network;../../../../../Middlewares/Third_Party/IOTA_C/core;../../../../../Middlewares/Third_Party/IOTA_C/core/models;../../../../../Middlewares/Third_Party/IOTA_C/core/models/inputs;../../../../../Middlewares/Third_Party/IOTA_C/core/models/outputs;../../../../../Middlewares/Third_Party/IOTA_C/core/models/payloads;../../../../../Middlewares/Third_Party/IOTA_C/core/utils;../../../../../Middlewares/Third_Party/IOTA_C/crypto;../../../../../Middlewares/Third_Party/IOTA_C/wallet;../../../../../Middlewares/Third_Party/libsodium/include;../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../Middlewares/Third_Party/tinyhttp;../../../../../Middlewares/Third_Party/Unity;../../../../../Middlewares/Third_Party/uthash
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: .\Project.sct
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0
